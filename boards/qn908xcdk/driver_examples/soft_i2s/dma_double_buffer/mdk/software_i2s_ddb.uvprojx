# Keil uVision project software_i2s_ddb.uvprojx, settings and files
target software_i2s_ddb Debug (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: QN9080B NXP
  pack: Keil.QN908x_DFP.1.1.0
  cpu: IROM(0x00000000,0x40000) IROM2(0x00000000,0x00000) IRAM(0x04000400,0xFC00) IRAM2(0x00000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: software_i2s_ddb.out
  AfterMake: fromelf.exe --bin -o "output\@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG, CPU_QN908X, CFG_QN908XC, SOFTWARE_I2S_32MHZ_AHB
  c misc: --library_interface=armcc 
--library_type=standardlib 
--diag_suppress=66,1296,186
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/QN908XC;../../../../../../platform/drivers;../../../../../../platform/drivers/common;../../../..;..;../../../../../src/driver_examples/soft_i2s/adpcm;../../../../../../platform/utilities/debug_console;../../../../../../platform/drivers/flexcomm;../../../../../../platform/drivers/flexcomm;../../../../../../platform/drivers/qn_gpio;../../../../../../platform/drivers/sctimer;../../../../../../platform/drivers/flexcomm;../../../../../../platform/drivers/lpc_dma;../../../../../../platform/drivers/flexcomm;../../../../../../platform/drivers/software_i2s;../../../../../../platform/drivers/common;../../../../../../platform/utilities/debug_console;../../../../../../devices/QN908XC;../../../../../../devices/QN908XC;../../../../../../platform/drivers/qn_iocon;../../../../../../platform/drivers/qn_syscon;../../../../../../devices/QN908XC;../../../../../../platform/drivers/qn_inputmux;../../../../../../devices/QN908XC;../../../../../../platform/utilities/debug_console;../../adpcm
  asm define: DEBUG
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000400 size 0xfc00
  scatter file: ../../../../../../devices/QN908XC/arm/QN908XC.scf
  link misc: --remove
  group startup
    ../../../../../../devices/QN908XC/arm/: startup_QN908XC.s
    ../../../../../../devices/QN908XC/: system_QN908XC.c system_QN908XC.h
  group doc
    ../: readme.txt
  group drivers
    ../../../../../../platform/drivers/flexcomm/: fsl_usart.h fsl_usart.c fsl_flexcomm.h fsl_flexcomm.c fsl_spi.c fsl_spi.h fsl_spi_dma.c fsl_spi_dma.h
    ../../../../../../platform/drivers/qn_gpio/: fsl_gpio.h fsl_gpio.c
    ../../../../../../platform/drivers/sctimer/: fsl_sctimer.h fsl_sctimer.c
    ../../../../../../platform/drivers/lpc_dma/: fsl_dma.c fsl_dma.h
    ../../../../../../platform/drivers/software_i2s/: fsl_software_i2s.h fsl_software_i2s.c
    ../../../../../../platform/drivers/common/: fsl_common.h fsl_common.c
    ../../../../../../devices/QN908XC/: fsl_clock.h fsl_clock.c fsl_power.h fsl_power.c fsl_inputmux_connections.h
    ../../../../../../platform/drivers/qn_iocon/: fsl_iocon.h
    ../../../../../../platform/drivers/qn_syscon/: fsl_syscon.h
    ../../../../../../platform/drivers/qn_inputmux/: fsl_inputmux.h fsl_inputmux.c
  group source
    ../: main.c
  group adpcm
    ../../adpcm/: adpcm.c adpcm.h
  group board
    ../: pin_mux.c pin_mux.h hardware_init.c app.h
    ../../../../: board.c board.h clock_config.c clock_config.h
  group utilities
    ../../../../../../platform/utilities/debug_console/: fsl_debug_console.c fsl_debug_console.h
target software_i2s_ddb Release (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: QN9080B NXP
  pack: Keil.QN908x_DFP.1.1.0
  cpu: as above
  output: software_i2s_ddb.out
  AfterMake: fromelf.exe --bin -o "output\@L.bin" "#L"
  AfterMake: nxp_bin_merger.exe -s sbl.bin -o ota.bin -d dfu.bin -a "output\@L.bin" -O "output\xjh.bin"
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: NDEBUG, CPU_QN908X, CFG_QN908XC, SOFTWARE_I2S_32MHZ_AHB
  c misc: as above
  c include: ../../../../../../CMSIS/Include;../../../../../../devices;../../../../../../devices/QN908XC;../../../../../../platform/drivers;../../../../../../platform/drivers/common;../../../..;..;../../../../../src/driver_examples/soft_i2s/adpcm;../../../../../../platform/utilities/debug_console;../../../../../../platform/drivers/flexcomm;../../adpcm;../../../../../../platform/drivers/qn_gpio;../../../../../../platform/drivers/sctimer;../../../../../../platform/drivers/flexcomm;../../../../../../platform/drivers/lpc_dma;../../../../../../platform/drivers/flexcomm;../../../../../../platform/drivers/software_i2s;../../../../../../platform/drivers/common;../../../../../../platform/utilities/debug_console;../../../../../../devices/QN908XC;../../../../../../devices/QN908XC;../../../../../../platform/drivers/qn_iocon;../../../../../../platform/drivers/qn_syscon;../../../../../../devices/QN908XC;../../../../../../platform/drivers/qn_inputmux;../../../../../../devices/QN908XC;../../../../../../platform/utilities/debug_console;../../../../../../devices/QN908XC
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x4000400 size 0xfc00
  scatter file: ../../../../../../devices/QN908XC/arm/QN908XC.scf
  link misc: --remove
